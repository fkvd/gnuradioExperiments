options:
  parameters:
    author: fkvd
    generate_options: qt_gui
    id: txpluto
    output_language: python
    title: NBFM transmitter with adalm pluto
  states: {}

blocks:
- name: isOn
  id: variable
  parameters:
    value: isOnSwitch
  states: {}
- name: isOnSwitch
  id: variable_qtgui_toggle_switch
  parameters:
    initPressed: 'False'
    label: Off / On
    position: '3'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '720000'
  states: {}
- name: source_switch
  id: variable_qtgui_chooser
  parameters:
    label: Source
    label0: File
    label1: Microphone
    label2: Sine wave
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: source_switch_variable
  id: variable
  parameters:
    value: source_switch
  states: {}
- name: tx_frequency
  id: variable
  parameters:
    comment: Do not change!
    value: '433900000'
  states: {}
- name: tx_power
  id: variable_qtgui_range
  parameters:
    comment: Higher values transmit with lower power
    label: Transmit power
    start: '1.00'
    step: '1'
    stop: '70.0'
    value: '30.0'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: '48000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: source_switch_variable
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: isOn
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: test48khz.wav
    repeat: 'True'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_power
    bandwidth: '200000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: tx_frequency
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '3000'
    win: window.WIN_HAMMING
  states: {}

connections:
- [analog_nbfm_tx_0, '0', low_pass_filter_0, '0']
- [analog_sig_source_x_0, '0', blocks_selector_0, '2']
- [audio_source_0, '0', blocks_selector_0, '1']
- [blocks_selector_0, '0', blocks_selector_1, '0']
- [blocks_selector_1, '0', blocks_null_sink_0, '0']
- [blocks_selector_1, '1', analog_nbfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_selector_0, '0']
- [low_pass_filter_0, '0', iio_pluto_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
