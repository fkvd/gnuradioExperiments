options:
  parameters:
    author: fkvd
    generate_options: qt_gui
    id: txpluto
    output_language: python
    title: Time switched selector block usage
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: int(2e6)
  states: {}
- name: tx_frequency
  id: variable
  parameters:
    comment: Do not change!
    value: '433900000'
  states: {}
- name: tx_power
  id: variable_qtgui_range
  parameters:
    comment: Higher values transmit with lower power
    label: Transmit power
    start: '1.00'
    step: '1'
    stop: '70.0'
    value: '30.0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '10000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '20000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport timeit\n\nclass blk(gr.sync_block):\n\t\"\"\" Selector with time - This blocks choose next input after timeout occurs\n\tYou can change number of parameters by editing default value of numInputs\n\tNote: This is not a time precise block\n\t\"\"\"\n\n\tdef __init__(self, timeout=1):\n\t\n\t\tnumInputs = 3\t# You can change this parameter\n\t\t\n\t\tgr.sync_block.__init__(\n\t\t\tself,\n\t\t\tname='Selector with time',\n\t\t\tin_sig=[np.complex64 for x in range(numInputs)],\n\t\t\tout_sig=[np.complex64]\n\t\t)\n\t\tself.timeout = timeout\n\t\tself.numInputs = numInputs\n\t\tself.startTime = timeit.default_timer()\n\t\tself.currentIndex = 0\n\n\tdef work(self, input_items, output_items):\n\t\tcurrentTime = timeit.default_timer()\n\t\ttimeDiff = currentTime - self.startTime\n\t\tif timeDiff > self.timeout:\n\t\t\tself.currentIndex = (self.currentIndex + 1) % self.numInputs\n\t\t\tself.startTime = currentTime\n\t\t\n\t\toutput_items[0][:] = input_items[self.currentIndex]\n\t\t\n\t\treturn len(output_items[0])\n\t\n"
    timeout: '0.1'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_power
    bandwidth: '200000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: tx_frequency
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}

connections:
- [analog_sig_source_x_0, '0', epy_block_0, '0']
- [analog_sig_source_x_0_0, '0', epy_block_0, '1']
- [analog_sig_source_x_0_0_0, '0', epy_block_0, '2']
- [epy_block_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', iio_pluto_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
