options:
  parameters:
    author: fkvd
    generate_options: qt_gui
    id: FrequencyHopper
    output_language: python
    title: Frequency Hopper
  states: {}

blocks:
- name: hoppingFrequency
  id: variable
  parameters:
    value: '1'
  states: {}
- name: hoppingSamplingRate
  id: variable
  parameters:
    value: 720e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '720000'
  states: {}
- name: tx_frequency
  id: variable
  parameters:
    comment: Do not change!
    value: '433900000'
  states: {}
- name: tx_power
  id: variable_qtgui_range
  parameters:
    comment: Higher values transmit with lower power
    label: Transmit power
    start: '1.00'
    step: '1'
    stop: '70.0'
    value: '44'
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '3000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: frequencyHopper_0
  id: frequencyHopper
  parameters:
    frequency: hoppingFrequency
    initial_phase: '0'
    samp_rate: hoppingSamplingRate
  states: {}
- name: frequencyHopper_0_0
  id: frequencyHopper
  parameters:
    frequency: hoppingFrequency
    initial_phase: math.pi
    samp_rate: hoppingSamplingRate
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_power
    bandwidth: '200000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: tx_frequency
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '200000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '20000'
    win: window.WIN_HAMMING
  states: {}

connections:
- [analog_sig_source_x_0_0_0, '0', frequencyHopper_0_0, '0']
- [analog_sig_source_x_0_1, '0', frequencyHopper_0, '0']
- [blocks_add_xx_1, '0', low_pass_filter_0, '0']
- [frequencyHopper_0, '0', blocks_add_xx_1, '0']
- [frequencyHopper_0_0, '0', blocks_add_xx_1, '1']
- [low_pass_filter_0, '0', iio_pluto_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
