options:
  parameters:
    author: fkvd
    generate_options: qt_gui
    id: multipleWBFM
    output_language: python
    title: Multiple WBFM Recorder
  states: {}

blocks:
- name: frequency
  id: variable
  parameters:
    value: 104.9e6
  states: {}
- name: pfb_taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1, samp_rate, 125e3, 100e3, 60)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: analog_fm_demod_cf_0_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '4'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: samp_rate/12
    deviation: '150000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_fm_demod_cf_0_0_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '4'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: samp_rate/12
    deviation: '150000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: 105.5.wav
    format: FORMAT_WAV
    samp_rate: '48000'
  states: {}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: 104.3.wav
    format: FORMAT_WAV
    samp_rate: '48000'
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate/12
    taps: firdes.low_pass(1,samp_rate/12, 100000, 3000)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate/12
    taps: firdes.low_pass(1,samp_rate/12, 100000, 3000)
    type: ccc
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      PFB Channelizers and Synthesizers
      https://www.trondeau.com/examples/2014/1/23/pfb-channelizers-and-synthesizers.html

      Designing Anaylsis and Synthesis Filterbanks in GNU Radio, 
      Thomas W. Rondeau, Timothy J. O’Shea
    note: References
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    ch_map: '[0, 1, 2, 3 ,4 ,5 ,6,7,8,9,10,11]'
    nchans: '12'
    osr: '1.0'
    taps: pfb_taps
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '48'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '48'
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: frequency
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: freq_104_3
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: freq_105_5
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: freq_104_3
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: freq_105_5
  states: {}

connections:
- [analog_fm_demod_cf_0_0, '0', rational_resampler_xxx_0_0, '0']
- [analog_fm_demod_cf_0_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_fm_demod_cf_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', analog_fm_demod_cf_0_0_0, '0']
- [pfb_channelizer_ccf_0, '0', blocks_null_sink_0, '0']
- [pfb_channelizer_ccf_0, '1', blocks_null_sink_0_0, '0']
- [pfb_channelizer_ccf_0, '10', blocks_null_sink_0_0_2, '0']
- [pfb_channelizer_ccf_0, '11', blocks_null_sink_0_0_0_2, '0']
- [pfb_channelizer_ccf_0, '2', blocks_null_sink_0_0_0, '0']
- [pfb_channelizer_ccf_0, '3', virtual_sink_1, '0']
- [pfb_channelizer_ccf_0, '4', blocks_null_sink_0_0_0_0, '0']
- [pfb_channelizer_ccf_0, '5', blocks_null_sink_0_1, '0']
- [pfb_channelizer_ccf_0, '6', blocks_null_sink_0_0_1, '0']
- [pfb_channelizer_ccf_0, '7', blocks_null_sink_0_0_0_1, '0']
- [pfb_channelizer_ccf_0, '8', blocks_null_sink_0_2, '0']
- [pfb_channelizer_ccf_0, '9', virtual_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_wavfile_sink_0, '0']
- [rational_resampler_xxx_0_0_0, '0', blocks_wavfile_sink_0_0, '0']
- [rtlsdr_source_0, '0', pfb_channelizer_ccf_0, '0']
- [virtual_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [virtual_source_1, '0', freq_xlating_fir_filter_xxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
