options:
  parameters:
    author: github.com/fkvd
    generate_options: qt_gui
    id: wbfm
    output_language: python
    title: FM Receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: analog_fm_demod_cf_0_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '5'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: samp_rate/10
    deviation: '150000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '100000'
    decim: '10'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 100000,10000)
    type: ccc
  states: {}
- name: rtlsdr_source_0_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 103.4e6
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0_0, '0', audio_sink_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_fm_demod_cf_0_0, '0']
- [rtlsdr_source_0_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
