options:
  parameters:
    author: fkvd
    description: This flowgraph scans all NBFM bands and tune into the channel which has maximum power
    generate_options: qt_gui
    id: nbfmScanner
    output_language: python
    title: Narrow Band FM Scanner
  states: {}

blocks:
- name: fft_length
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: frequency
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,1
    label: Frequency (MHz)
    type: real
    value: '433.5'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: RF Gain
    start: '1'
    step: '1'
    stop: '45'
    value: '10'
  states: {}
- name: output
  id: variable
  parameters:
    value: scanner_module.detect(variable_function_probe_0,samp_rate, threshold, frequency)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1
    label: Threshold
    start: '-100'
    step: '1'
    stop: '0'
    value: '-100'
  states: {}
- name: tuned_frequency
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    ThousandsSeparator: '.'
    gui_hint: 1,0
    lbl: Tuned frequency
    maxFreqHz: 1700e6
    minFreqHz: 30e6
    readOnly: 'True'
    value: output[0]
  states: {}
- name: variable_function_probe_0
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_spectrum
    function_name: level
    poll_rate: '1'
    value: '0'
  states: {}
- name: variable_qtgui_label_1
  id: variable_qtgui_label
  parameters:
    label: 'frequency shift: '
    type: int
    value: int(output[0]-frequency*1e6)
  states: {state: disabled}
- name: vector_length
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: threshold
    type: float
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '240000'
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-50'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: vector_length
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '100'
    type: float
    vlen: vector_length
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '1'
    type: complex
    vlen: vector_length
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.4'
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '-100'
    n: '10'
    vlen: vector_length
  states: {}
- name: blocks_probe_signal_spectrum
  id: blocks_probe_signal_vx
  parameters:
    type: float
    vlen: vector_length
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_length
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '240000'
    type: float
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_length
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_length)
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: (output[0]-frequency*1e6)
    decim: '10'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 2500, 500 )
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    nconnections: '2'
    vlen: vector_length
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: frequency*1e6
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: scanner_module
  id: epy_module
  parameters:
    source_code: "import numpy as np\r\n\r\ndef avg_freq_power(data):\r\n\tweighted_power = 0\r\n\tsum_power = 0\r\n\t\r\n\tfor index,sample in enumerate(data):\r\n\t\tweighted_power += index * float(sample)\r\n\t\tsum_power += float(sample)\r\n\t\t\r\n\tif len(data) <= 0:\r\n\t\treturn 0,0\r\n\telse:\r\n\t\treturn weighted_power/float(sum_power), sum_power\r\n\r\ndef estimate(spectrum, threshold):\r\n\t\r\n\tspectrum = np.append(spectrum, np.zeros(1))\r\n\tlength   = len(spectrum)\r\n\tchannels = []\r\n\tlnbins   = []\r\n\tbins     = []\r\n\tsum_powers = []\r\n\tindex    = 0\r\n\t\r\n\twhile index < length:\r\n\t\tif (spectrum[index] > threshold):\r\n\t\t\tbins.append(spectrum[index])\r\n\t\t\tindex += 1\r\n\t\t\t\r\n\t\telif (len(bins) > 3):\r\n\t\t\tavg_freq = avg_freq_power(bins)\r\n\t\t\tchannels.append(index - len(bins) + avg_freq[0])\r\n\t\t\t\r\n\t\t\tlnbins.append(len(bins))\r\n\t\t\tsum_powers.append(avg_freq[1])\r\n\t\t\tindex += 1\r\n\t\t\tbins = []\r\n\t\t\t\r\n\t\telse:\r\n\t\t\tindex += 1\r\n\t\t\t\t\t\r\n\treturn channels, lnbins, sum_powers\r\n\t\t\t\r\nchannels = []\r\nlnbin = []\r\nsum_powers = []\r\nret = [0,0, 0]\r\nchannel_spacing = 0.0005\r\n\r\nlast_frequency = 0\r\nlastFreqSet = False;\r\n\r\ndef detect(data, fs, threshold, freq):\r\n\tglobal channels, lnbin, ret, channel_spacing, sum_powers, last_frequency, lastFreqSet\r\n\t\r\n\tif(lastFreqSet == False):\r\n\t\tlast_frequency = freq\r\n\t\tlastFreqSet = True\r\n\t\r\n\ttry:\r\n\t\tspectrum = list(data)\r\n\t\tspectrum = np.array([float(x) for x in spectrum])\r\n\t\tchannels, lnbin, sum_powers = np.array(estimate(spectrum, threshold))\r\n\t\t\r\n\t\tif len(channels) > 0:\r\n\t\t\tresolution = fs / len(spectrum)\r\n\t\t\tchannels = (channels - len(spectrum)/2)*resolution\r\n\t\t\tchannels = np.round(channels/channel_spacing)*channel_spacing\r\n\t\t\tprint(channels, lnbin)\r\n\t\t\ttmpf = []\r\n\t\t\tfor ch in channels:\r\n\t\t\t\ttuned_channels = np.round((ch+freq*1e6),3)\r\n\t\t\t\ttmpf.append(tuned_channels)\r\n\t\t\t\r\n\t\t\tchannels = tmpf\r\n\t\t\tidx = sum_powers.argmax(axis=0)\r\n\t\t\t#print(\"idx:\" + str(idx))\r\n\t\t\tret = [channels[idx], lnbin[idx], sum_powers[idx]]\r\n\t\t\tlast_frequency = channels[idx]\r\n\t\telse:\r\n\t\t\tret = [last_frequency,0,0]\r\n\t\r\n\texcept Exception as e:\r\n\t\tprint(e)\r\n\t\tpass\r\n\t\r\n\tprint(ret)\r\n\treturn ret\r\n\r\n"
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: sdrOutput
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: sdrOutput
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_throttle_0, '0']
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_integrate_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_keep_one_in_n_0, '0', fft_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_probe_signal_spectrum, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_stream_to_vector_1, '0', qtgui_vector_sink_f_0, '1']
- [blocks_throttle_0, '0', blocks_stream_to_vector_1, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', analog_simple_squelch_cc_0, '0']
- [rtlsdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [rtlsdr_source_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
