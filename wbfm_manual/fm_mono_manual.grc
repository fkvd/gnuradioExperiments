options:
  parameters:
    author: fkvd
    generate_options: qt_gui
    id: fm_mono_manual
    output_language: python
    title: FM Mono Manual
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: volumeControl
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.4'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate/10
    tau: '75e-6'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    comment: Play sound
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volumeControl
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    comment: Record sound
    file: decodedMonoFM.wav
    format: FORMAT_WAV
    samp_rate: '48000'
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '100000'
    comment: Frequency Shifting + LPF + Decimation
    decim: '10'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 100000,10000)
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '5'
    gain: '1'
    samp_rate: samp_rate/10
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    alias: References
    comment: |-
      1) FM DEMODULATION USING A DIGITAL RADIO AND 
      DIGITAL SIGNAL PROCESSING, Figure 4.2
      Author: James Michael Shima

      2) witestlab.poly.edu/blog/capture-and-decode-fm-radio
      Author: Fraida Fund
    note: References
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/10
    comment: |-
      You can see how the spectrum allocated for mono
      channel, stereo channel and pilot signal similar to:
      en.wikipedia.org/wiki/FM_broadcasting
    fc: '0'
    fftsize: '1024'
    name: '"Deemphasis"'
    type: float
  states: {}
- name: rtlsdr_source_0_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    comment: |-
      We want to listen 103.5 MHz. However frequency is set to
      103.4 MHz in order to avoid DC offset. In the next block
      we will shift frequency by 0.1 MHz.
    freq0: 103.4e6
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: basebandFM
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: basebandFM
  states: {}

connections:
- [analog_fm_deemph_0, '0', low_pass_filter_0, '0']
- [analog_fm_deemph_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_complex_to_magphase_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_magphase_0, '1', analog_fm_deemph_0, '0']
- [blocks_delay_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_magphase_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_wavfile_sink_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', virtual_sink_1, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [rtlsdr_source_0_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [virtual_source_1, '0', blocks_delay_0, '0']
- [virtual_source_1, '0', blocks_multiply_conjugate_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
